v {xschem version=3.0.0 file_version=1.2 }
G {}
K {}
V {}
S {}
E {}
N 180 -160 180 -120 {
lab=in}
N 180 -60 180 -20 {
lab=out}
C {res.sym} 180 -90 2 0 {name=R1
value=0.1
footprint=1206
device=resistor
m=1}
C {ipin.sym} 180 -150 1 0 {name=p1 lab=in}
C {ipin.sym} 180 -30 3 0 {name=p2 lab=out}
